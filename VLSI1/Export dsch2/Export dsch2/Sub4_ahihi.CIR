CIRCUIT D:\download\VLSI1\Export dsch2\Export dsch2\Sub4_ahihi.MSK
*
* IC Technology: CMOS 0.25µm - 6 Metal
*
VDD 1 0 DC 2.50
VA1 99 0 DC 0 PULSE(0.00 2.50 3.95N 0.05N 0.05N 3.95N 8.00N)
VA2 105 0 DC 0 PULSE(0.00 2.50 1.95N 0.05N 0.05N 1.95N 4.00N)
VA0 111 0 DC 0 PULSE(0.00 2.50 7.95N 0.05N 0.05N 7.95N 16.00N)
VA3 117 0 DC 0 PULSE(0.00 2.50 0.95N 0.05N 0.05N 0.95N 2.00N)
VA5 123 0 DC 0 PULSE(0.00 2.50 3.95N 0.05N 0.05N 3.95N 8.00N)
VA6 129 0 DC 0 PULSE(0.00 2.50 1.95N 0.05N 0.05N 1.95N 4.00N)
VA4 135 0 DC 0 PULSE(0.00 2.50 7.95N 0.05N 0.05N 7.95N 16.00N)
VA7 141 0 DC 0 PULSE(0.00 2.50 0.95N 0.05N 0.05N 0.95N 2.00N)
VB7 142 0 DC 0 PULSE(0.00 2.50 15.95N 0.05N 0.05N 15.95N 32.00N)
VB5 143 0 DC 0 PULSE(0.00 2.50 63.95N 0.05N 0.05N 63.95N 128.00N)
VB4 144 0 DC 0 PULSE(0.00 2.50 127.95N 0.05N 0.05N 127.95N 256.00N)
VB6 146 0 DC 0 PULSE(0.00 2.50 31.95N 0.05N 0.05N 31.95N 64.00N)
VB2 147 0 DC 0 PULSE(0.00 2.50 31.95N 0.05N 0.05N 31.95N 64.00N)
VB1 148 0 DC 0 PULSE(0.00 2.50 63.95N 0.05N 0.05N 63.95N 128.00N)
VB0 149 0 DC 0 PULSE(0.00 2.50 127.95N 0.05N 0.05N 127.95N 256.00N)
VB3 150 0 DC 0 PULSE(0.00 2.50 15.95N 0.05N 0.05N 15.95N 32.00N)
*
* List of nodes
* "N4" corresponds to n°4
* "N6" corresponds to n°6
* "N7" corresponds to n°7
* "N8" corresponds to n°8
* "N9" corresponds to n°9
* "out1" corresponds to n°12
* "out2" corresponds to n°22
* "out0" corresponds to n°32
* "out3" corresponds to n°42
* "out5" corresponds to n°57
* "out6" corresponds to n°67
* "out4" corresponds to n°77
* "Carry" corresponds to n°80
* "out7" corresponds to n°87
* "A1" corresponds to n°99
* "N100" corresponds to n°100
* "N101" corresponds to n°101
* "N102" corresponds to n°102
* "N103" corresponds to n°103
* "N104" corresponds to n°104
* "A2" corresponds to n°105
* "N106" corresponds to n°106
* "N107" corresponds to n°107
* "N108" corresponds to n°108
* "N109" corresponds to n°109
* "N110" corresponds to n°110
* "A0" corresponds to n°111
* "N112" corresponds to n°112
* "N113" corresponds to n°113
* "N114" corresponds to n°114
* "N115" corresponds to n°115
* "N116" corresponds to n°116
* "A3" corresponds to n°117
* "N118" corresponds to n°118
* "N119" corresponds to n°119
* "N120" corresponds to n°120
* "N121" corresponds to n°121
* "N122" corresponds to n°122
* "A5" corresponds to n°123
* "N124" corresponds to n°124
* "N125" corresponds to n°125
* "N126" corresponds to n°126
* "N127" corresponds to n°127
* "N128" corresponds to n°128
* "A6" corresponds to n°129
* "N130" corresponds to n°130
* "N131" corresponds to n°131
* "N132" corresponds to n°132
* "N133" corresponds to n°133
* "N134" corresponds to n°134
* "A4" corresponds to n°135
* "N136" corresponds to n°136
* "N137" corresponds to n°137
* "N138" corresponds to n°138
* "N139" corresponds to n°139
* "N140" corresponds to n°140
* "A7" corresponds to n°141
* "B7" corresponds to n°142
* "B5" corresponds to n°143
* "B4" corresponds to n°144
* "B6" corresponds to n°146
* "B2" corresponds to n°147
* "B1" corresponds to n°148
* "B0" corresponds to n°149
* "B3" corresponds to n°150
*
* MOS devices
MN1 94 6 4 0 N1  W= 0.75U L= 0.25U
MN2 95 7 94 0 N1  W= 0.75U L= 0.25U
MN3 0 8 95 0 N1  W= 0.75U L= 0.25U
MN4 96 25 6 0 N1  W= 0.75U L= 0.25U
MN5 0 99 96 0 N1  W= 0.75U L= 0.25U
MN6 97 25 7 0 N1  W= 0.75U L= 0.25U
MN7 0 46 97 0 N1  W= 0.75U L= 0.25U
MN8 98 99 8 0 N1  W= 0.75U L= 0.25U
MN9 0 46 98 0 N1  W= 0.75U L= 0.25U
MN10 0 10 9 0 N1  W= 0.75U L= 0.25U
MN11 99 46 10 0 N1  W= 0.75U L= 0.25U
MN12 0 99 11 0 N1  W= 0.75U L= 0.25U
MN13 0 13 12 0 N1  W= 0.75U L= 0.25U
MN14 9 25 13 0 N1  W= 0.75U L= 0.25U
MN15 0 9 14 0 N1  W= 0.75U L= 0.25U
MN16 100 16 15 0 N1  W= 0.75U L= 0.25U
MN17 101 17 100 0 N1  W= 0.75U L= 0.25U
MN18 0 18 101 0 N1  W= 0.75U L= 0.25U
MN19 102 4 16 0 N1  W= 0.75U L= 0.25U
MN20 0 105 102 0 N1  W= 0.75U L= 0.25U
MN21 103 4 17 0 N1  W= 0.75U L= 0.25U
MN22 0 45 103 0 N1  W= 0.75U L= 0.25U
MN23 104 105 18 0 N1  W= 0.75U L= 0.25U
MN24 0 45 104 0 N1  W= 0.75U L= 0.25U
MN25 0 20 19 0 N1  W= 0.75U L= 0.25U
MN26 105 45 20 0 N1  W= 0.75U L= 0.25U
MN27 0 105 21 0 N1  W= 0.75U L= 0.25U
MN28 0 23 22 0 N1  W= 0.75U L= 0.25U
MN29 19 4 23 0 N1  W= 0.75U L= 0.25U
MN30 0 19 24 0 N1  W= 0.75U L= 0.25U
MN31 106 26 25 0 N1  W= 0.75U L= 0.25U
MN32 107 27 106 0 N1  W= 0.75U L= 0.25U
MN33 0 28 107 0 N1  W= 0.75U L= 0.25U
MN34 108 1 26 0 N1  W= 0.75U L= 0.25U
MN35 0 111 108 0 N1  W= 0.75U L= 0.25U
MN36 109 1 27 0 N1  W= 0.75U L= 0.25U
MN37 0 47 109 0 N1  W= 0.75U L= 0.25U
MN38 110 111 28 0 N1  W= 0.75U L= 0.25U
MN39 0 47 110 0 N1  W= 0.75U L= 0.25U
MN40 0 30 29 0 N1  W= 0.75U L= 0.25U
MN41 111 47 30 0 N1  W= 0.75U L= 0.25U
MN42 0 111 31 0 N1  W= 0.75U L= 0.25U
MN43 0 33 32 0 N1  W= 0.75U L= 0.25U
MN44 29 1 33 0 N1  W= 0.75U L= 0.25U
MN45 0 29 34 0 N1  W= 0.75U L= 0.25U
MN46 112 36 35 0 N1  W= 0.75U L= 0.25U
MN47 113 37 112 0 N1  W= 0.75U L= 0.25U
MN48 0 38 113 0 N1  W= 0.75U L= 0.25U
MN49 114 15 36 0 N1  W= 0.75U L= 0.25U
MN50 0 117 114 0 N1  W= 0.75U L= 0.25U
MN51 115 15 37 0 N1  W= 0.75U L= 0.25U
MN52 0 48 115 0 N1  W= 0.75U L= 0.25U
MN53 116 117 38 0 N1  W= 0.75U L= 0.25U
MN54 0 48 116 0 N1  W= 0.75U L= 0.25U
MN55 0 40 39 0 N1  W= 0.75U L= 0.25U
MN56 117 48 40 0 N1  W= 0.75U L= 0.25U
MN57 0 117 41 0 N1  W= 0.75U L= 0.25U
MN58 0 43 42 0 N1  W= 0.75U L= 0.25U
MN59 39 15 43 0 N1  W= 0.75U L= 0.25U
MN60 0 39 44 0 N1  W= 0.75U L= 0.25U
MN61 0 147 45 0 N1  W= 0.75U L= 0.25U
MN62 0 148 46 0 N1  W= 0.75U L= 0.25U
MN63 0 149 47 0 N1  W= 0.75U L= 0.25U
MN64 0 150 48 0 N1  W= 0.75U L= 0.25U
MN65 118 51 49 0 N1  W= 0.75U L= 0.25U
MN66 119 52 118 0 N1  W= 0.75U L= 0.25U
MN67 0 53 119 0 N1  W= 0.75U L= 0.25U
MN68 120 70 51 0 N1  W= 0.75U L= 0.25U
MN69 0 123 120 0 N1  W= 0.75U L= 0.25U
MN70 121 70 52 0 N1  W= 0.75U L= 0.25U
MN71 0 91 121 0 N1  W= 0.75U L= 0.25U
MN72 122 123 53 0 N1  W= 0.75U L= 0.25U
MN73 0 91 122 0 N1  W= 0.75U L= 0.25U
MN74 0 55 54 0 N1  W= 0.75U L= 0.25U
MN75 123 91 55 0 N1  W= 0.75U L= 0.25U
MN76 0 123 56 0 N1  W= 0.75U L= 0.25U
MN77 0 58 57 0 N1  W= 0.75U L= 0.25U
MN78 54 70 58 0 N1  W= 0.75U L= 0.25U
MN79 0 54 59 0 N1  W= 0.75U L= 0.25U
MN80 124 61 60 0 N1  W= 0.75U L= 0.25U
MN81 125 62 124 0 N1  W= 0.75U L= 0.25U
MN82 0 63 125 0 N1  W= 0.75U L= 0.25U
MN83 126 49 61 0 N1  W= 0.75U L= 0.25U
MN84 0 129 126 0 N1  W= 0.75U L= 0.25U
MN85 127 49 62 0 N1  W= 0.75U L= 0.25U
MN86 0 90 127 0 N1  W= 0.75U L= 0.25U
MN87 128 129 63 0 N1  W= 0.75U L= 0.25U
MN88 0 90 128 0 N1  W= 0.75U L= 0.25U
MN89 0 65 64 0 N1  W= 0.75U L= 0.25U
MN90 129 90 65 0 N1  W= 0.75U L= 0.25U
MN91 0 129 66 0 N1  W= 0.75U L= 0.25U
MN92 0 68 67 0 N1  W= 0.75U L= 0.25U
MN93 64 49 68 0 N1  W= 0.75U L= 0.25U
MN94 0 64 69 0 N1  W= 0.75U L= 0.25U
MN95 130 71 70 0 N1  W= 0.75U L= 0.25U
MN96 131 72 130 0 N1  W= 0.75U L= 0.25U
MN97 0 73 131 0 N1  W= 0.75U L= 0.25U
MN98 132 35 71 0 N1  W= 0.75U L= 0.25U
MN99 0 135 132 0 N1  W= 0.75U L= 0.25U
MN100 133 35 72 0 N1  W= 0.75U L= 0.25U
MN101 0 92 133 0 N1  W= 0.75U L= 0.25U
MN102 134 135 73 0 N1  W= 0.75U L= 0.25U
MN103 0 92 134 0 N1  W= 0.75U L= 0.25U
MN104 0 75 74 0 N1  W= 0.75U L= 0.25U
MN105 135 92 75 0 N1  W= 0.75U L= 0.25U
MN106 0 135 76 0 N1  W= 0.75U L= 0.25U
MN107 0 78 77 0 N1  W= 0.75U L= 0.25U
MN108 74 35 78 0 N1  W= 0.75U L= 0.25U
MN109 0 74 79 0 N1  W= 0.75U L= 0.25U
MN110 136 81 80 0 N1  W= 0.75U L= 0.25U
MN111 137 82 136 0 N1  W= 0.75U L= 0.25U
MN112 0 83 137 0 N1  W= 0.75U L= 0.25U
MN113 138 60 81 0 N1  W= 0.75U L= 0.25U
MN114 0 141 138 0 N1  W= 0.75U L= 0.25U
MN115 139 60 82 0 N1  W= 0.75U L= 0.25U
MN116 0 93 139 0 N1  W= 0.75U L= 0.25U
MN117 140 141 83 0 N1  W= 0.75U L= 0.25U
MN118 0 93 140 0 N1  W= 0.75U L= 0.25U
MN119 0 85 84 0 N1  W= 0.75U L= 0.25U
MN120 141 93 85 0 N1  W= 0.75U L= 0.25U
MN121 0 141 86 0 N1  W= 0.75U L= 0.25U
MN122 0 88 87 0 N1  W= 0.75U L= 0.25U
MN123 84 60 88 0 N1  W= 0.75U L= 0.25U
MN124 0 84 89 0 N1  W= 0.75U L= 0.25U
MN125 0 146 90 0 N1  W= 0.75U L= 0.25U
MN126 0 143 91 0 N1  W= 0.75U L= 0.25U
MN127 0 144 92 0 N1  W= 0.75U L= 0.25U
MN128 0 142 93 0 N1  W= 0.75U L= 0.25U
MP1 1 6 4 1 P1  W= 2.00U L= 0.25U
MP2 4 7 1 1 P1  W= 2.00U L= 0.25U
MP3 1 8 4 1 P1  W= 2.00U L= 0.25U
MP4 6 25 1 1 P1  W= 2.00U L= 0.25U
MP5 1 99 6 1 P1  W= 2.00U L= 0.25U
MP6 7 25 1 1 P1  W= 2.00U L= 0.25U
MP7 1 46 7 1 P1  W= 2.00U L= 0.25U
MP8 8 99 1 1 P1  W= 2.00U L= 0.25U
MP9 1 46 8 1 P1  W= 2.00U L= 0.25U
MP10 1 10 9 1 P1  W= 2.00U L= 0.25U
MP11 11 46 10 1 P1  W= 2.00U L= 0.25U
MP12 1 99 11 1 P1  W= 2.00U L= 0.25U
MP13 1 13 12 1 P1  W= 2.00U L= 0.25U
MP14 14 25 13 1 P1  W= 2.00U L= 0.25U
MP15 1 9 14 1 P1  W= 2.00U L= 0.25U
MP16 1 16 15 1 P1  W= 2.00U L= 0.25U
MP17 15 17 1 1 P1  W= 2.00U L= 0.25U
MP18 1 18 15 1 P1  W= 2.00U L= 0.25U
MP19 16 4 1 1 P1  W= 2.00U L= 0.25U
MP20 1 105 16 1 P1  W= 2.00U L= 0.25U
MP21 17 4 1 1 P1  W= 2.00U L= 0.25U
MP22 1 45 17 1 P1  W= 2.00U L= 0.25U
MP23 18 105 1 1 P1  W= 2.00U L= 0.25U
MP24 1 45 18 1 P1  W= 2.00U L= 0.25U
MP25 1 20 19 1 P1  W= 2.00U L= 0.25U
MP26 21 45 20 1 P1  W= 2.00U L= 0.25U
MP27 1 105 21 1 P1  W= 2.00U L= 0.25U
MP28 1 23 22 1 P1  W= 2.00U L= 0.25U
MP29 24 4 23 1 P1  W= 2.00U L= 0.25U
MP30 1 19 24 1 P1  W= 2.00U L= 0.25U
MP31 1 26 25 1 P1  W= 2.00U L= 0.25U
MP32 25 27 1 1 P1  W= 2.00U L= 0.25U
MP33 1 28 25 1 P1  W= 2.00U L= 0.25U
MP34 26 1 1 1 P1  W= 2.00U L= 0.25U
MP35 1 111 26 1 P1  W= 2.00U L= 0.25U
MP36 27 1 1 1 P1  W= 2.00U L= 0.25U
MP37 1 47 27 1 P1  W= 2.00U L= 0.25U
MP38 28 111 1 1 P1  W= 2.00U L= 0.25U
MP39 1 47 28 1 P1  W= 2.00U L= 0.25U
MP40 1 30 29 1 P1  W= 2.00U L= 0.25U
MP41 31 47 30 1 P1  W= 2.00U L= 0.25U
MP42 1 111 31 1 P1  W= 2.00U L= 0.25U
MP43 1 33 32 1 P1  W= 2.00U L= 0.25U
MP44 34 1 33 1 P1  W= 2.00U L= 0.25U
MP45 1 29 34 1 P1  W= 2.00U L= 0.25U
MP46 1 36 35 1 P1  W= 2.00U L= 0.25U
MP47 35 37 1 1 P1  W= 2.00U L= 0.25U
MP48 1 38 35 1 P1  W= 2.00U L= 0.25U
MP49 36 15 1 1 P1  W= 2.00U L= 0.25U
MP50 1 117 36 1 P1  W= 2.00U L= 0.25U
MP51 37 15 1 1 P1  W= 2.00U L= 0.25U
MP52 1 48 37 1 P1  W= 2.00U L= 0.25U
MP53 38 117 1 1 P1  W= 2.00U L= 0.25U
MP54 1 48 38 1 P1  W= 2.00U L= 0.25U
MP55 1 40 39 1 P1  W= 2.00U L= 0.25U
MP56 41 48 40 1 P1  W= 2.00U L= 0.25U
MP57 1 117 41 1 P1  W= 2.00U L= 0.25U
MP58 1 43 42 1 P1  W= 2.00U L= 0.25U
MP59 44 15 43 1 P1  W= 2.00U L= 0.25U
MP60 1 39 44 1 P1  W= 2.00U L= 0.25U
MP61 1 147 45 1 P1  W= 2.00U L= 0.25U
MP62 1 148 46 1 P1  W= 2.00U L= 0.25U
MP63 1 149 47 1 P1  W= 2.00U L= 0.25U
MP64 1 150 48 1 P1  W= 2.00U L= 0.25U
MP65 1 51 49 1 P1  W= 2.00U L= 0.25U
MP66 49 52 1 1 P1  W= 2.00U L= 0.25U
MP67 1 53 49 1 P1  W= 2.00U L= 0.25U
MP68 51 70 1 1 P1  W= 2.00U L= 0.25U
MP69 1 123 51 1 P1  W= 2.00U L= 0.25U
MP70 52 70 1 1 P1  W= 2.00U L= 0.25U
MP71 1 91 52 1 P1  W= 2.00U L= 0.25U
MP72 53 123 1 1 P1  W= 2.00U L= 0.25U
MP73 1 91 53 1 P1  W= 2.00U L= 0.25U
MP74 1 55 54 1 P1  W= 2.00U L= 0.25U
MP75 56 91 55 1 P1  W= 2.00U L= 0.25U
MP76 1 123 56 1 P1  W= 2.00U L= 0.25U
MP77 1 58 57 1 P1  W= 2.00U L= 0.25U
MP78 59 70 58 1 P1  W= 2.00U L= 0.25U
MP79 1 54 59 1 P1  W= 2.00U L= 0.25U
MP80 1 61 60 1 P1  W= 2.00U L= 0.25U
MP81 60 62 1 1 P1  W= 2.00U L= 0.25U
MP82 1 63 60 1 P1  W= 2.00U L= 0.25U
MP83 61 49 1 1 P1  W= 2.00U L= 0.25U
MP84 1 129 61 1 P1  W= 2.00U L= 0.25U
MP85 62 49 1 1 P1  W= 2.00U L= 0.25U
MP86 1 90 62 1 P1  W= 2.00U L= 0.25U
MP87 63 129 1 1 P1  W= 2.00U L= 0.25U
MP88 1 90 63 1 P1  W= 2.00U L= 0.25U
MP89 1 65 64 1 P1  W= 2.00U L= 0.25U
MP90 66 90 65 1 P1  W= 2.00U L= 0.25U
MP91 1 129 66 1 P1  W= 2.00U L= 0.25U
MP92 1 68 67 1 P1  W= 2.00U L= 0.25U
MP93 69 49 68 1 P1  W= 2.00U L= 0.25U
MP94 1 64 69 1 P1  W= 2.00U L= 0.25U
MP95 1 71 70 1 P1  W= 2.00U L= 0.25U
MP96 70 72 1 1 P1  W= 2.00U L= 0.25U
MP97 1 73 70 1 P1  W= 2.00U L= 0.25U
MP98 71 35 1 1 P1  W= 2.00U L= 0.25U
MP99 1 135 71 1 P1  W= 2.00U L= 0.25U
MP100 72 35 1 1 P1  W= 2.00U L= 0.25U
MP101 1 92 72 1 P1  W= 2.00U L= 0.25U
MP102 73 135 1 1 P1  W= 2.00U L= 0.25U
MP103 1 92 73 1 P1  W= 2.00U L= 0.25U
MP104 1 75 74 1 P1  W= 2.00U L= 0.25U
MP105 76 92 75 1 P1  W= 2.00U L= 0.25U
MP106 1 135 76 1 P1  W= 2.00U L= 0.25U
MP107 1 78 77 1 P1  W= 2.00U L= 0.25U
MP108 79 35 78 1 P1  W= 2.00U L= 0.25U
MP109 1 74 79 1 P1  W= 2.00U L= 0.25U
MP110 1 81 80 1 P1  W= 2.00U L= 0.25U
MP111 80 82 1 1 P1  W= 2.00U L= 0.25U
MP112 1 83 80 1 P1  W= 2.00U L= 0.25U
MP113 81 60 1 1 P1  W= 2.00U L= 0.25U
MP114 1 141 81 1 P1  W= 2.00U L= 0.25U
MP115 82 60 1 1 P1  W= 2.00U L= 0.25U
MP116 1 93 82 1 P1  W= 2.00U L= 0.25U
MP117 83 141 1 1 P1  W= 2.00U L= 0.25U
MP118 1 93 83 1 P1  W= 2.00U L= 0.25U
MP119 1 85 84 1 P1  W= 2.00U L= 0.25U
MP120 86 93 85 1 P1  W= 2.00U L= 0.25U
MP121 1 141 86 1 P1  W= 2.00U L= 0.25U
MP122 1 88 87 1 P1  W= 2.00U L= 0.25U
MP123 89 60 88 1 P1  W= 2.00U L= 0.25U
MP124 1 84 89 1 P1  W= 2.00U L= 0.25U
MP125 1 146 90 1 P1  W= 2.00U L= 0.25U
MP126 1 143 91 1 P1  W= 2.00U L= 0.25U
MP127 1 144 92 1 P1  W= 2.00U L= 0.25U
MP128 1 142 93 1 P1  W= 2.00U L= 0.25U
*
C2 1 0 242.465fF
C3 1 0 242.465fF
C4 4 0 14.416fF
C6 6 0  5.471fF
C7 7 0  5.842fF
C8 8 0  5.625fF
C9 9 0  6.778fF
C10 10 0  2.882fF
C11 11 0  2.733fF
C12 12 0 12.487fF
C13 13 0  2.882fF
C14 14 0  2.733fF
C15 15 0 16.996fF
C16 16 0  5.471fF
C17 17 0  6.235fF
C18 18 0  6.245fF
C19 19 0  6.778fF
C20 20 0  2.882fF
C21 21 0  2.733fF
C22 22 0 10.104fF
C23 23 0  2.882fF
C24 24 0  2.733fF
C25 25 0 13.162fF
C26 26 0  6.092fF
C27 27 0  5.481fF
C28 28 0  5.821fF
C29 29 0  6.582fF
C30 30 0  2.882fF
C31 31 0  2.733fF
C32 32 0  7.720fF
C33 33 0  2.882fF
C34 34 0  2.733fF
C35 35 0 23.651fF
C36 36 0  5.275fF
C37 37 0  6.431fF
C38 38 0  6.410fF
C39 39 0  7.367fF
C40 40 0  2.882fF
C41 41 0  2.733fF
C42 42 0  5.140fF
C43 43 0  2.882fF
C44 44 0  2.733fF
C45 45 0 14.371fF
C46 46 0 15.948fF
C47 47 0 12.043fF
C48 48 0 10.325fF
C49 49 0 14.416fF
C51 51 0  5.471fF
C52 52 0  5.842fF
C53 53 0  5.625fF
C54 54 0  6.778fF
C55 55 0  2.882fF
C56 56 0  2.733fF
C57 57 0 12.487fF
C58 58 0  2.882fF
C59 59 0  2.733fF
C60 60 0 16.996fF
C61 61 0  5.471fF
C62 62 0  6.235fF
C63 63 0  6.214fF
C64 64 0  6.778fF
C65 65 0  2.882fF
C66 66 0  2.733fF
C67 67 0 10.104fF
C68 68 0  2.882fF
C69 69 0  2.733fF
C70 70 0 13.162fF
C71 71 0  6.060fF
C72 72 0  5.450fF
C73 73 0  5.821fF
C74 74 0  6.582fF
C75 75 0  2.882fF
C76 76 0  2.733fF
C77 77 0  7.720fF
C78 78 0  2.882fF
C79 79 0  2.733fF
C80 80 0  8.314fF
C81 81 0  5.275fF
C82 82 0  6.431fF
C83 83 0  6.410fF
C84 84 0  7.367fF
C85 85 0  2.882fF
C86 86 0  2.733fF
C87 87 0  5.140fF
C88 88 0  2.882fF
C89 89 0  2.733fF
C90 90 0 14.371fF
C91 91 0 15.948fF
C92 92 0 12.043fF
C93 93 0 10.325fF
C94 94 0  0.473fF
C95 95 0  0.473fF
C96 96 0  0.473fF
C97 97 0  0.473fF
C98 98 0  0.473fF
C99 99 0 17.228fF
C100 100 0  0.473fF
C101 101 0  0.473fF
C102 102 0  0.473fF
C103 103 0  0.473fF
C104 104 0  0.473fF
C105 105 0 14.451fF
C106 106 0  0.473fF
C107 107 0  0.473fF
C108 108 0  0.473fF
C109 109 0  0.473fF
C110 110 0  0.473fF
C111 111 0 11.675fF
C112 112 0  0.473fF
C113 113 0  0.473fF
C114 114 0  0.473fF
C115 115 0  0.473fF
C116 116 0  0.473fF
C117 117 0  8.310fF
C118 118 0  0.473fF
C119 119 0  0.473fF
C120 120 0  0.473fF
C121 121 0  0.473fF
C122 122 0  0.473fF
C123 123 0 17.228fF
C124 124 0  0.473fF
C125 125 0  0.473fF
C126 126 0  0.473fF
C127 127 0  0.473fF
C128 128 0  0.473fF
C129 129 0 14.451fF
C130 130 0  0.473fF
C131 131 0  0.473fF
C132 132 0  0.473fF
C133 133 0  0.473fF
C134 134 0  0.473fF
C135 135 0 11.675fF
C136 136 0  0.473fF
C137 137 0  0.473fF
C138 138 0  0.473fF
C139 139 0  0.473fF
C140 140 0  0.473fF
C141 141 0  8.310fF
C142 142 0  1.254fF
C143 143 0  1.800fF
C144 144 0  1.527fF
C145 1 0 10.158fF
C146 146 0  2.073fF
C147 147 0  2.073fF
C148 148 0  1.800fF
C149 149 0  1.527fF
C150 150 0  1.254fF
*
*
* n-MOS BSIM4 :
* Standard
.MODEL N1 NMOS LEVEL=14 VTHO=0.45 U0=0.062 TOXE= 5.0E-9 LINT=-0.010U
+K1 =0.170 K2=0.100 DVT0=2.300
+DVT1=0.540 LPE0=23.000e-9 ETA0=0.080
+NFACTOR=  3.0 U0=0.062 UA=7.000e-15
+WINT=0.020U LPE0=23.000e-9
+KT1=-0.060 UTE=-1.800 VOFF=0.050
+XJ=0.150U NDEP=170.000e15 PCLM=0.290
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p
*
* p-MOS BSIM4:
* Standard
.MODEL P1 PMOS LEVEL=14 VTHO=-0.45 U0=0.010 TOXE= 5.0E-9 LINT=-0.040U
+K1 =0.290 K2=0.100 DVT0=2.300
+DVT1=0.540 LPE0=23.000e-9 ETA0=0.080
+NFACTOR=  2.2 U0=0.010 UA=1.000e-15
+WINT=0.020U LPE0=23.000e-9
+KT1=-0.060 UTE=-1.800 VOFF=0.050
+XJ=0.150U NDEP=170.000e15 PCLM=0.300
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p
*
* Transient analysis
*
* (Winspice)
.options temp=27.0
.control
tran 0.1N 50.00N
print  V(123) V(57) V(129) V(67) V(135) V(77) V(80) V(141) V(87) V(146) V(143) V(144) V(142) V(149) V(148) V(147) V(42) V(117) V(150)  > out.txt
plot  V(123) V(57) V(129) V(67) V(135) V(77) V(80) V(141) V(87) V(146) V(143) V(144) V(142) V(149) V(148) V(147) V(42) V(117) V(150)
.endc
.END
